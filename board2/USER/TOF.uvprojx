# Keil uVision project TOF.uvprojx, settings and files
target TOF (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TOF +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\USART2;..\SENSOR;..\HARDWARE\USART3;..\SENSOR;..\HARDWARE\UART4;..\HARDWARE\UART5;..\HARDWARE\WDG;..\HARDWARE\BC26;..\HARDWARE\TIMER;..\HARDWARE\KEY
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/UART4/: uart4.c
    ../HARDWARE/UART5/: uart5.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/BC26/: BC26.c
    ../HARDWARE/KEY/: switch.c
    ../HARDWARE/TIMER/: pwm.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_iwdg.c
  group SENSOR
    ../SENSOR/: ms53l0m.c ms53l0m_first.c ms53l0m_third.c ms53l0m_second.c
  group README
    ../: README.TXT
